# Keil uVision project WreckerCar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: WreckerCar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c action.c adc.c delay.c IIC.c MPU6050.c oled.c timer.c uart.c A4988.c external.c uart2.c TB6612.c
